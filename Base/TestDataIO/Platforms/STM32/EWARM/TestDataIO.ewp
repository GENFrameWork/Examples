# IAR project TestDataIO.ewp, settings and files
configuration TestDataIO (ARM, debug)
  General.OGChipSelectEditMenu: STM32WB55RG ST STM32WB55RG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STM32WBXX_NUCLEO; USE_HAL_DRIVER; STM32WB55xx; HW_STM32
  ICCARM.CCIncludePath2: ../FATFS/Target; ../FATFS/App; ../Core/Inc; ../Drivers/STM32WBxx_HAL_Driver/Inc; ../Drivers/STM32WBxx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FatFs/src; ../Drivers/CMSIS/Device/ST/STM32WBxx/Include; ../Drivers/CMSIS/Include; ..\..\..\..\..\..\GEN\Application; ..\..\..\..\..\..\GEN\DataIO; ..\..\..\..\..\..\GEN\DataIO\I2C; ..\..\..\..\..\..\GEN\DataIO\SPI; ..\..\..\..\..\..\GEN\MainProc; ..\..\..\..\..\..\GEN\Platforms\Microcontrollers\STM32; ..\..\..\..\..\..\GEN\Utils; ..\..\..\..\..\..\GEN\Common; ..\..\..\Application; ..\..\..\..\..\..\GEN\Cipher
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: TestDataIO.hex
  ILINK.IlinkOutputFile: TestDataIO.out
  ILINK.IlinkIcfFile: stm32wb55xx_flash_cm4.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32wb55xx_cm4.s
  group Application/Main
    ../../../Application/: APP_GEN_Defines.h TestDataIO.cpp TestDataIO_STM32Platform.cpp
  group Application/User/Core
    ../Core/Src/: main.c stm32wbxx_it.c stm32wbxx_hal_msp.c
  group Application/User/FATFS/App
    ../FATFS/App/: app_fatfs.c
  group Application/User/FATFS/Target
    ../FATFS/Target/: user_diskio.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32wbxx.c
  group Drivers/STM32WBxx_HAL_Driver
    ../Drivers/STM32WBxx_HAL_Driver/Src/: stm32wbxx_hal_rcc.c stm32wbxx_hal_rcc_ex.c stm32wbxx_hal_flash.c stm32wbxx_hal_flash_ex.c stm32wbxx_hal_gpio.c stm32wbxx_hal_hsem.c stm32wbxx_hal_dma.c stm32wbxx_hal_dma_ex.c stm32wbxx_hal_pwr.c stm32wbxx_hal_pwr_ex.c stm32wbxx_hal_cortex.c stm32wbxx_hal.c stm32wbxx_hal_exti.c stm32wbxx_hal_i2c.c stm32wbxx_hal_i2c_ex.c stm32wbxx_hal_spi.c stm32wbxx_hal_spi_ex.c stm32wbxx_hal_tim.c stm32wbxx_hal_tim_ex.c stm32wbxx_hal_uart.c stm32wbxx_hal_uart_ex.c
  group GEN/Application
    ../../../../../../GEN/Application/: APPBase.cpp APPMain.cpp
  group GEN/DataIO
    ../../../../../../GEN/DataIO/: DIODevice.cpp DIODeviceI2C.cpp DIODeviceSPI.cpp DIODisplayDevice.cpp DIOFactory.cpp DIOGPIO.cpp DIOLedNeoPixelWS2812B.cpp DIOStream.cpp DIOStreamConfig.cpp DIOStreamDevice.cpp DIOStreamI2C.cpp DIOStreamI2CConfig.cpp DIOStreamSPI.cpp DIOStreamSPIConfig.cpp DIOStreamUART.cpp DIOStreamUARTConfig.cpp
  group GEN/DataIO/I2C
    ../../../../../../GEN/DataIO/I2C/: DIOI2C6AxisTrackingLSM303DLHC.cpp DIOI2C9AxisTrackingMPU9150.cpp DIOI2CADDAConverterPCF8591.cpp DIOI2CAirQualityCCS811.cpp DIOI2CEEprom24XXX.cpp DIOI2CGPIOMCP2317.cpp DIOI2CGPIOPCF8574.cpp DIOI2CLightSensorTSL2561.cpp DIOI2CMonitorGaugeLTC2942.cpp DIOI2COLEDDisplaySSD1306.cpp DIOI2CPWMControlerPCA9685.cpp DIOI2CTemHumSensorAM2315.cpp DIOI2CTemHumSensorSHT20.cpp
  group GEN/DataIO/SPI
    ../../../../../../GEN/DataIO/SPI/: DIOSPIGPIOMCP23S17.cpp DIOSPILCDDisplayPCF8833.cpp DIOSPIOLEDDisplaySSD1306.cpp DIOSPIOLEDDisplaySSD1331.cpp DIOSPITFTDisplayILI9341.cpp DIOSPITFTDisplayST7789.cpp DIOSPITouchScreenSTMPE610.cpp
  group GEN/MainProc
    ../../../../../../GEN/MainProc/: MainProc.cpp
  group GEN/Platform
    ../../../../../../GEN/Platforms/Microcontrollers/STM32/: DIOSTM32Factory.cpp DIOSTM32GPIO.cpp DIOSTM32LedNeoPixelWS2812B.cpp DIOSTM32StreamI2C.cpp DIOSTM32StreamSPI.cpp DIOSTM32StreamUART.cpp MainProcSTM32.cpp XSTM32_FATSD_SPI.cpp XSTM32DateTime.cpp XSTM32Dir.cpp XSTM32EEPROMMemoryManager.cpp XSTM32Factory.cpp XSTM32File.cpp XSTM32Rand.cpp XSTM32Sleep.cpp XSTM32System.cpp XSTM32Thread.cpp XSTM32Timer.cpp XSTM32Trace.cpp
  group GEN/Utils
    ../../../../../../GEN/Utils/: XBase.cpp XBuffer.cpp XDateTime.cpp XDir.cpp XEEPROMMemoryManager.cpp XEvent.cpp XFactory.cpp XFile.cpp XFSMachine.cpp XLanguage_ISO_639_3.cpp XMemory_Control.cpp XObserver.cpp XPath.cpp XPathsManager.cpp XPublisher.cpp XRand.cpp XSleep.cpp XString.cpp XSubject.cpp XSystem.cpp XThread.cpp XThreadCollected.cpp XThreadListNonPreemptive.cpp XTimer.cpp XTrace.cpp XTranslation.cpp XTranslation_GEN.cpp XVariant.cpp
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c ccsbcs.c
